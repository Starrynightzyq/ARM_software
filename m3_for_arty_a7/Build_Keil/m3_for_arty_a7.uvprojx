# Keil uVision project m3_for_arty_a7.uvprojx, settings and files
target m3_for_arty_a7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 ARTY_CM3
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM3;..\main;..\gpio;..\uart;..\spi;..\iic;..\vdma;..\cmos;..\image;..\timer;..\lcd;..\delay;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include
  memory RVCT4: ROM 0x0 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry=Reset_Handler
  group CMSIS
    ../cmsis/Device/Source/ARTY_CM3/: system_ARTY_CM3.c
    ../cmsis/Device/Source/ARTY_CM3/ARM/: startup_ARTY_CM3.s
  group Standalone_v6_7
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/standalone_v6_7/src/: outbyte.c print.c xil_assert.c xil_printf.c usleep.c sleep.c xtime_l.c xil_sleepcommon.c xil_sleeptimer.c
  group Main
    ../main/: main.c
  group GPIO
    ../gpio/: gpio.c
  group UART
    ../uart/: uart.c
  group IIC
    ../iic/: iic.c
  group VDMA
    ../vdma/: vdma.c vdma_driver.c
  group CMOS
    ../cmos/: cmos.c
  group IMAGE
    ../image/: image.c
  group TIMER
    ../timer/: timer.c
  group LCD
    ../lcd/: spi_my.c lcd.c
  group DELAY
    ../delay/: delay.c
  group Xilinx_GPIO
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/gpio_v4_3/src/: xgpio.c xgpio_extra.c xgpio_g.c xgpio_intr.c xgpio_selftest.c xgpio_sinit.c
  group Xilinx_SPI
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/spi_v4_4/src/: xspi.c xspi_g.c xspi_options.c xspi_selftest.c xspi_sinit.c xspi_stats.c
  group Xilinx_UART
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/uartlite_v3_2/src/: xuartlite.c xuartlite_g.c xuartlite_intr.c xuartlite_l.c xuartlite_selftest.c xuartlite_sinit.c xuartlite_stats.c
  group Xilinx_IIC
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/iic_v3_4/src/: xiic.c xiic_dyn_master.c xiic_g.c xiic_intr.c xiic_l.c xiic_master.c xiic_multi_master.c xiic_options.c xiic_selftest.c xiic_sinit.c xiic_slave.c xiic_stats.c
  group Xilinx_VDMA
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/axivdma_v6_5/src/: xaxivdma.c xaxivdma_channel.c xaxivdma_g.c xaxivdma_intr.c xaxivdma_selftest.c xaxivdma_sinit.c
  group Xilinx_TIMER
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/tmrctr_v4_4/src/: xtmrctr.c xtmrctr_g.c xtmrctr_intr.c xtmrctr_l.c xtmrctr_options.c xtmrctr_selftest.c xtmrctr_sinit.c xtmrctr_stats.c
  group HLS_Threshold2
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/threshold2_v1_3/src/: xthreshold2.c xthreshold2_g.c xthreshold2_sinit.c
  group HLS_Projection1
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/projection1_hls_v4_3/src/: xprojection1_hls.c xprojection1_hls_g.c xprojection1_hls_sinit.c
  group HLS_Mask
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/mask_v2_2/src/: xmask.c xmask_g.c xmask_sinit.c
  group HLS_Projection_mul
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/projection_mul_hls_v1_0/src/: xprojection_mul_hls.c xprojection_mul_hls_g.c xprojection_mul_hls_sinit.c
  group HLS_Resize
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/resize_hls_axis_v1_0/src/: xresize_hls_axis.c xresize_hls_axis_g.c xresize_hls_axis_sinit.c
  group HLS_Contrast
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/contrast_hls_rom_v1_3/src/: xcontrast_hls_rom.c xcontrast_hls_rom_g.c xcontrast_hls_rom_sinit.c
  group HLS_Drawlines
    ../sdk_workspace/standalone_bsp_0/Cortex_M3_0/libsrc/draw_line_hls_v1_1/src/: xdraw_line_hls.c xdraw_line_hls_g.c xdraw_line_hls_sinit.c
target m3_for_arty_a7_sim (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: m3_for_arty_a7 +hex
  AfterMake: make_hex_a7.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M1 ARTY_CM1 SIM_BUILD
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\cmsis\Device\Include\ARTY_CM1;..\sdk_workspace\standalone_bsp_0\Cortex_M3_0\include;..\main;..\platform;..\gpio;..\uart;..\spi
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.0.2
